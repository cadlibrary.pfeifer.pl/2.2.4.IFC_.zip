Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture], Option [ExcludedObjects: , , , , , , , , , , , , , , , , , , ,]
Time: 2021-06-25T09:38:27
Author: bock
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: AutoCAD Architecture 2020 - Deutsch (German) Build 8.2.47.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 25 09:38:27 2021 * Host: c10119 * Database: C:\Users\bock\AppData\Local\Temp\ACAIFCTMP/EDM12084\aec_ifc_db * Database version: 5507 * Database creation date: Fri Jun 25 09:38:07 2021 * Schema: IFC4 * Model: DataRepository.AecIfc * Model creation date: Fri Jun 25 09:38:26 2021 * Header model: DataRepository.AecIfc_Header * Header model creation date: Fri Jun 25 09:38:26 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 1
LongName: Pfeifer
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Modell

# IfcBuilding, Pfeifer
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
